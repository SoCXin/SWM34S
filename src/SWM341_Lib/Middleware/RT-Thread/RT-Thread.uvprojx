# Keil uVision project RT-Thread.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.18.1
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: RT-Thread
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;.\APP;.\APP\rt-thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: main.c
    ./APP/: board.c
  group RT-Thread
    ./APP/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread\Port
    ./APP/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group CSL\StdPD
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_exti.c SWM341_gpio.c SWM341_i2c.c SWM341_pwm.c SWM341_timr.c SWM341_uart.c SWM341_wdt.c SWM341_dma.c SWM341_flash.c SWM341_port.c SWM341_spi.c SWM341_can.c SWM341_crc.c SWM341_lcd.c SWM341_rtc.c
  group CSL\CMSIS
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s

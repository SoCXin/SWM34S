# Keil uVision project MSC_BOT.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.20.2
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: MSC_BOT +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;..\..\SWM341_StdPeriph_Driver\CSL\SWM341_UsbHost_Lib;..\..\SWM341_StdPeriph_Driver\CSL\SWM341_UsbHost_Lib\MSC;.\APP;.\APP\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: main.c
    ./APP/: usbh_user.c
  group FATFS
    ./APP/FatFs/: ff.c diskio.c ffunicode.c
  group USBH
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_UsbHost_Lib/: usbh_core.c usbh_stdreq.c
  group USBH\MSC
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_UsbHost_Lib/MSC/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group CSL\StdPD
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_exti.c SWM341_gpio.c SWM341_i2c.c SWM341_pwm.c SWM341_timr.c SWM341_uart.c SWM341_wdt.c SWM341_dma.c SWM341_flash.c SWM341_port.c SWM341_spi.c SWM341_can.c SWM341_crc.c SWM341_lcd.c SWM341_rtc.c SWM341_cordic.c SWM341_dac.c SWM341_div.c SWM341_jpeg.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_usbd.c SWM341_usbh.c
  group CSL\CMSIS
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
